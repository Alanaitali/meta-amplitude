DESCRIPTION = "Amplitude image minimal, to get the hardware running"
LICENSE = "MIT"

inherit amplitude-base-image
